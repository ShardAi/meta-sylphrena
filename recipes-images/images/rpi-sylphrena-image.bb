require core-image-base

IMAGE_INSTALL += "sylphrena-core"
IMAGE_INSTALL += "sylphrena-input"
