require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "sylphrena-core"
IMAGE_INSTALL += "sylphrena-input"
