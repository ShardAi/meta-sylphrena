require core-image-base

IMAGE_INSTALL += "sylphrena-input"
